## boards/goodbyte/BTZ_EndDevice/Kconfig.BTZ_EndDevice
```kconfig
config BOARD_BTZ_ENDDEVICE
	select SOC_NRF54L15_CPUAPP if BOARD_BTZ_ENDDEVICE_NRF54L15_CPUAPP
```
